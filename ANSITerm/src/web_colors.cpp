#include "web_colors.h"

// Function implementation to get color by name
Color getWebColor(const char* name) {
    if (strcmp(name, "aliceblue") == 0) return COLOR_ALICEBLUE;
    if (strcmp(name, "antiquewhite") == 0) return COLOR_ANTIQUEWHITE;
    if (strcmp(name, "aqua") == 0) return COLOR_AQUA;
    if (strcmp(name, "aquamarine") == 0) return COLOR_AQUAMARINE;
    if (strcmp(name, "azure") == 0) return COLOR_AZURE;
    if (strcmp(name, "beige") == 0) return COLOR_BEIGE;
    if (strcmp(name, "bisque") == 0) return COLOR_BISQUE;
    if (strcmp(name, "black") == 0) return COLOR_BLACK;
    if (strcmp(name, "blanchedalmond") == 0) return COLOR_BLANCHEDALMOND;
    if (strcmp(name, "blue") == 0) return COLOR_BLUE;
    if (strcmp(name, "blueviolet") == 0) return COLOR_BLUEVIOLET;
    if (strcmp(name, "brown") == 0) return COLOR_BROWN;
    if (strcmp(name, "burlywood") == 0) return COLOR_BURLYWOOD;
    if (strcmp(name, "cadetblue") == 0) return COLOR_CADETBLUE;
    if (strcmp(name, "chartreuse") == 0) return COLOR_CHARTREUSE;
    if (strcmp(name, "chocolate") == 0) return COLOR_CHOCOLATE;
    if (strcmp(name, "coral") == 0) return COLOR_CORAL;
    if (strcmp(name, "cornflowerblue") == 0) return COLOR_CORNFLOWERBLUE;
    if (strcmp(name, "cornsilk") == 0) return COLOR_CORNSILK;
    if (strcmp(name, "crimson") == 0) return COLOR_CRIMSON;
    if (strcmp(name, "cyan") == 0) return COLOR_CYAN;
    if (strcmp(name, "darkblue") == 0) return COLOR_DARKBLUE;
    if (strcmp(name, "darkcyan") == 0) return COLOR_DARKCYAN;
    if (strcmp(name, "darkgoldenrod") == 0) return COLOR_DARKGOLDENROD;
    if (strcmp(name, "darkgray") == 0) return COLOR_DARKGRAY;
    if (strcmp(name, "darkgreen") == 0) return COLOR_DARKGREEN;
    if (strcmp(name, "darkkhaki") == 0) return COLOR_DARKKHAKI;
    if (strcmp(name, "darkmagenta") == 0) return COLOR_DARKMAGENTA;
    if (strcmp(name, "darkolivegreen") == 0) return COLOR_DARKOLIVEGREEN;
    if (strcmp(name, "darkorange") == 0) return COLOR_DARKORANGE;
    if (strcmp(name, "darkorchid") == 0) return COLOR_DARKORCHID;
    if (strcmp(name, "darkred") == 0) return COLOR_DARKRED;
    if (strcmp(name, "darksalmon") == 0) return COLOR_DARKSALMON;
    if (strcmp(name, "darkseagreen") == 0) return COLOR_DARKSEAGREEN;
    if (strcmp(name, "darkslateblue") == 0) return COLOR_DARKSLATEBLUE;
    if (strcmp(name, "darkslategray") == 0) return COLOR_DARKSLATEGRAY;
    if (strcmp(name, "darkturquoise") == 0) return COLOR_DARKTURQUOISE;
    if (strcmp(name, "darkviolet") == 0) return COLOR_DARKVIOLET;
    if (strcmp(name, "deeppink") == 0) return COLOR_DEEPPINK;
    if (strcmp(name, "deepskyblue") == 0) return COLOR_DEEPSKYBLUE;
    if (strcmp(name, "dimgray") == 0) return COLOR_DIMGRAY;
    if (strcmp(name, "dodgerblue") == 0) return COLOR_DODGERBLUE;
    if (strcmp(name, "firebrick") == 0) return COLOR_FIREBRICK;
    if (strcmp(name, "floralwhite") == 0) return COLOR_FLORALWHITE;
    if (strcmp(name, "forestgreen") == 0) return COLOR_FORESTGREEN;
    if (strcmp(name, "fuchsia") == 0) return COLOR_FUCHSIA;
    if (strcmp(name, "gainsboro") == 0) return COLOR_GAINSBORO;
    if (strcmp(name, "ghostwhite") == 0) return COLOR_GHOSTWHITE;
    if (strcmp(name, "gold") == 0) return COLOR_GOLD;
    if (strcmp(name, "goldenrod") == 0) return COLOR_GOLDENROD;
    if (strcmp(name, "gray") == 0) return COLOR_GRAY;
    if (strcmp(name, "green") == 0) return COLOR_GREEN;
    if (strcmp(name, "greenyellow") == 0) return COLOR_GREENYELLOW;
    if (strcmp(name, "honeydew") == 0) return COLOR_HONEYDEW;
    if (strcmp(name, "hotpink") == 0) return COLOR_HOTPINK;
    if (strcmp(name, "indianred") == 0) return COLOR_INDIANRED;
    if (strcmp(name, "indigo") == 0) return COLOR_INDIGO;
    if (strcmp(name, "ivory") == 0) return COLOR_IVORY;
    if (strcmp(name, "khaki") == 0) return COLOR_KHAKI;
    if (strcmp(name, "lavender") == 0) return COLOR_LAVENDER;
    if (strcmp(name, "lavenderblush") == 0) return COLOR_LAVENDERBLUSH;
    if (strcmp(name, "lawngreen") == 0) return COLOR_LAWNGREEN;
    if (strcmp(name, "lemonchiffon") == 0) return COLOR_LEMONCHIFFON;
    if (strcmp(name, "lightblue") == 0) return COLOR_LIGHTBLUE;
    if (strcmp(name, "lightcoral") == 0) return COLOR_LIGHTCORAL;
    if (strcmp(name, "lightcyan") == 0) return COLOR_LIGHTCYAN;
    if (strcmp(name, "lightgoldenrodyellow") == 0) return COLOR_LIGHTGOLDENRODYELLOW;
    if (strcmp(name, "lightgray") == 0) return COLOR_LIGHTGRAY;
    if (strcmp(name, "lightgreen") == 0) return COLOR_LIGHTGREEN;
    if (strcmp(name, "lightpink") == 0) return COLOR_LIGHTPINK;
    if (strcmp(name, "lightsalmon") == 0) return COLOR_LIGHTSALMON;
    if (strcmp(name, "lightseagreen") == 0) return COLOR_LIGHTSEAGREEN;
    if (strcmp(name, "lightskyblue") == 0) return COLOR_LIGHTSKYBLUE;
    if (strcmp(name, "lightslategray") == 0) return COLOR_LIGHTSLATEGRAY;
    if (strcmp(name, "lightsteelblue") == 0) return COLOR_LIGHTSTEELBLUE;
    if (strcmp(name, "lightyellow") == 0) return COLOR_LIGHTYELLOW;
    if (strcmp(name, "lime") == 0) return COLOR_LIME;
    if (strcmp(name, "limegreen") == 0) return COLOR_LIMEGREEN;
    if (strcmp(name, "linen") == 0) return COLOR_LINEN;
    if (strcmp(name, "magenta") == 0) return COLOR_MAGENTA;
    if (strcmp(name, "maroon") == 0) return COLOR_MAROON;
    if (strcmp(name, "mediumaquamarine") == 0) return COLOR_MEDIUMAQUAMARINE;
    if (strcmp(name, "mediumblue") == 0) return COLOR_MEDIUMBLUE;
    if (strcmp(name, "mediumorchid") == 0) return COLOR_MEDIUMORCHID;
    if (strcmp(name, "mediumpurple") == 0) return COLOR_MEDIUMPURPLE;
    if (strcmp(name, "mediumseagreen") == 0) return COLOR_MEDIUMSEAGREEN;
    if (strcmp(name, "mediumslateblue") == 0) return COLOR_MEDIUMSLATEBLUE;
    if (strcmp(name, "mediumspringgreen") == 0) return COLOR_MEDIUMSPRINGGREEN;
    if (strcmp(name, "mediumturquoise") == 0) return COLOR_MEDIUMTURQUOISE;
    if (strcmp(name, "mediumvioletred") == 0) return COLOR_MEDIUMVIOLETRED;
    if (strcmp(name, "midnightblue") == 0) return COLOR_MIDNIGHTBLUE;
    if (strcmp(name, "mintcream") == 0) return COLOR_MINTCREAM;
    if (strcmp(name, "mistyrose") == 0) return COLOR_MISTYROSE;
    if (strcmp(name, "moccasin") == 0) return COLOR_MOCCASIN;
    if (strcmp(name, "navajowhite") == 0) return COLOR_NAVAJOWHITE;
    if (strcmp(name, "navy") == 0) return COLOR_NAVY;
    if (strcmp(name, "oldlace") == 0) return COLOR_OLDLACE;
    if (strcmp(name, "olive") == 0) return COLOR_OLIVE;
    if (strcmp(name, "olivedrab") == 0) return COLOR_OLIVEDRAB;
    if (strcmp(name, "orange") == 0) return COLOR_ORANGE;
    if (strcmp(name, "orangered") == 0) return COLOR_ORANGERED;
    if (strcmp(name, "orchid") == 0) return COLOR_ORCHID;
    if (strcmp(name, "palegoldenrod") == 0) return COLOR_PALEGOLDENROD;
    if (strcmp(name, "palegreen") == 0) return COLOR_PALEGREEN;
    if (strcmp(name, "paleturquoise") == 0) return COLOR_PALETURQUOISE;
    if (strcmp(name, "palevioletred") == 0) return COLOR_PALEVIOLETRED;
    if (strcmp(name, "papayawhip") == 0) return COLOR_PAPAYAWHIP;
    if (strcmp(name, "peachpuff") == 0) return COLOR_PEACHPUFF;
    if (strcmp(name, "peru") == 0) return COLOR_PERU;
    if (strcmp(name, "pink") == 0) return COLOR_PINK;
    if (strcmp(name, "plum") == 0) return COLOR_PLUM;
    if (strcmp(name, "powderblue") == 0) return COLOR_POWDERBLUE;
    if (strcmp(name, "purple") == 0) return COLOR_PURPLE;
    if (strcmp(name, "red") == 0) return COLOR_RED;
    if (strcmp(name, "rosybrown") == 0) return COLOR_ROSYBROWN;
    if (strcmp(name, "royalblue") == 0) return COLOR_ROYALBLUE;
    if (strcmp(name, "saddlebrown") == 0) return COLOR_SADDLEBROWN;
    if (strcmp(name, "salmon") == 0) return COLOR_SALMON;
    if (strcmp(name, "sandybrown") == 0) return COLOR_SANDYBROWN;
    if (strcmp(name, "seagreen") == 0) return COLOR_SEAGREEN;
    if (strcmp(name, "seashell") == 0) return COLOR_SEASHELL;
    if (strcmp(name, "sienna") == 0) return COLOR_SIENNA;
    if (strcmp(name, "silver") == 0) return COLOR_SILVER;
    if (strcmp(name, "skyblue") == 0) return COLOR_SKYBLUE;
    if (strcmp(name, "slateblue") == 0) return COLOR_SLATEBLUE;
    if (strcmp(name, "slategray") == 0) return COLOR_SLATEGRAY;
    if (strcmp(name, "snow") == 0) return COLOR_SNOW;
    if (strcmp(name, "springgreen") == 0) return COLOR_SPRINGGREEN;
    if (strcmp(name, "steelblue") == 0) return COLOR_STEELBLUE;
    if (strcmp(name, "tan") == 0) return COLOR_TAN;
    if (strcmp(name, "teal") == 0) return COLOR_TEAL;
    if (strcmp(name, "thistle") == 0) return COLOR_THISTLE;
    if (strcmp(name, "tomato") == 0) return COLOR_TOMATO;
    if (strcmp(name, "turquoise") == 0) return COLOR_TURQUOISE;
    if (strcmp(name, "violet") == 0) return COLOR_VIOLET;
    if (strcmp(name, "wheat") == 0) return COLOR_WHEAT;
    if (strcmp(name, "white") == 0) return COLOR_WHITE;
    if (strcmp(name, "whitesmoke") == 0) return COLOR_WHITESMOKE;
    if (strcmp(name, "yellow") == 0) return COLOR_YELLOW;
    if (strcmp(name, "yellowgreen") == 0) return COLOR_YELLOWGREEN;

    // Default to black if color name is not found
    return COLOR_BLACK;
}